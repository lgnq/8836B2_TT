# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: DP80390XP Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000) MOD_CONT MODDP2 MOD517AU
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  asm include: .\src
  link misc: RECURSIONS (30)
  group Source Group 1
    ./: START390.A51
    ./src/: mcu.c
    ./main/: main.c
    ./scheduler/: ttc_sch_od_f85x_003-0_c02b.c
    ./system/: system_f85x_003-0_c02b.c
    ./tasks/: heartbeat_f85x_003-0_c02b.c watchdog_f85x_003-0_c02a.c
